# Autodesk Inventor part: 7T167-100Q-uzsakovui
## iProperties
Created: 2010-09
Part Number: 7T167-100Q-uzsakovui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
